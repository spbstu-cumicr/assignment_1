# Keil uVision project lab_1.uvprojx, settings and files
target target_1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab_1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=2
  c define: STM32F407xx, STM32F40_41xxx, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, USE_HSE, HSE_VALUE=8000000
  c misc: -fno-exceptions -fno-threadsafe-statics -fdata-sections -ffunction-sections --system-header-prefix=./src/spl/inc --system-header-prefix=./src/cmsis --system-header-prefix=./src/mcu_support_package/inc -Wall -Wpedantic -Wextra -Wvla -Wshadow -Wmissing-format-attribute -Wuninitialized -Winit-self -Wdouble-promotion -Wstrict-aliasing -Wno-c++98-compat-pedantic -Wno-old-style-cast -Wno-deprecated-register -Wno-inconsistent-missing-override -Wno-empty-body -Wno-extra-semi-stmt -Wno-covered-switch-default -Wno-missing-noreturn -Wno-unreachable-code-return -Wno-macro-redefined -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-declaration-after-statement -Wno-padded -Wno-cast-qual -Wno-missing-prototypes -Wno-unused-but-set-variable
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\spl\inc;.\src\spl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/main/: main.c
  group msu_support_package
    ./src/mcu_support_package/src/: system_stm32f4xx.c
    ./src/mcu_support_package/arm/: startup_stm32f407xx.s
  group spl
    ./src/spl/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group test
    ./src/test/: test.h test.lib
